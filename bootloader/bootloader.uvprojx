# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  output: bootloader
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F405xx
  c include: .;cherryusb;freertos;library;main;start;tlsf;ware
  memory RVCT1: RAM 0x08000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x10000000 size 0x10000
  group cherryusb
    cherryusb/: usbd_core.c usbd_msc.c usb_dc_dwc2.c usb_glue_st.c usb_osal_freertos.c
  group freertos
    freertos/: list.c port.c queue.c tasks.c timers.c
  group library
    library/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group main
    main/: bootloader.c stm32f4xx_it.c
  group start
    start/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group tlsf
    tlsf/: malloc.c tlsf.c
  group ware
    ware/: bootuf2.c chip_rom.c img_crc.c key.c lcd_bsp.c nvic_conf.c pin_ctrl.c systick_conf.c usbd_msc_conf.c
