# Keil uVision project Brahman.uvprojx, settings and files
target Brahman (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  output: Brahman
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F405xx,LV_LVGL_H_INCLUDE_SIMPLE,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --diag_suppress=1 --diag_suppress=1295 --no-multibyte-chars
  c include: .;library;main;start;ware\lib\FreeRTOS;.cmsis\include;ware\BSP;ware\tool;ware\lib\TLSF;ware\lib\Fatfs;ware\lib\FlashDB;ware\Tasks;ware\GUI\GUI_Page;ware\APP\Music;ware\lib\LVGL\bsp;ware\lib\LVGL\core;ware\lib\LVGL\draw;ware\lib\LVGL\extra;ware\lib\LVGL\font;ware\lib\LVGL\gpu;ware\lib\LVGL\hal;ware\lib\LVGL\misc;ware\lib\LVGL\widgets;ware\GUI\GUI_Unit;ware\APP\Media;ware\lib\PNGdec;ware\lib\Tjpgd;ware\lib\AnimatedGIF;ware\lib\Music;ware\lib\Music\AAC;ware\lib\Music\APE;ware\lib\Music\FLAC;ware\lib\Music\MP3;ware\lib\Music\OGG;ware\APP\Text;ware\APP\USB;ware\APP\NES;ware\APP\NES\mapper;ware\lib\Cherry_USB\core;ware\lib\Cherry_USB\common;ware\lib\Cherry_USB\class\audio;ware\lib\Cherry_USB\class\cdc;ware\lib\Cherry_USB\class\gamepad;ware\lib\Cherry_USB\class\hid;ware\lib\Cherry_USB\class\hub;ware\lib\Cherry_USB\class\msc;ware\lib\Cherry_USB\class\serial;ware\lib\Cherry_USB\class\vendor\display;ware\lib\Letter_Shell
  memory RVCT4: ROM 0x08010000 size 0xF0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    main/: main.c stm32f4xx_it.c variables.c
  group ware/tool
    ware/tool/: cpu_usage.c debug.c fontupd.c kvdb_ctrl.c lunar.c pinyin_dict.c pinyin_find.c spectrum_dsp.c tsdb_log.c v2p_bat.c
  group ware/Tasks
    ware/Tasks/: basic_task.c fileop_task.c font_task.c game_task.c lvgl_task.c media_task.c music_task.c task_manager.c usb_task.c
  group ware/lib/TLSF
    ware/lib/TLSF/: malloc.c tlsf.c
  group ware/lib/Tjpgd
    ware/lib/Tjpgd/: tjpgd.c
  group ware/lib/PNGdec
    ware/lib/PNGdec/: adler32.c infback.c inffast.c inflate.c inftrees.c PNGdec.c zutil.c
  group ware/lib/Music/OGG
    ware/lib/Music/OGG/: stb_vorbis.c
  group ware/lib/Music/MP3
    ware/lib/Music/MP3/: asmmisc_rvds.s asmpoly_thumb2_rvds.s bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
  group ware/lib/Music/FLAC
    ware/lib/Music/FLAC/: foxen-flac.c
  group ware/lib/Music/APE
    ware/lib/Music/APE/: apedecoder.c crc.c entropy.c filter.c filter_16_11.c filter_32_10.c filter_64_11.c parser.c predictor-arm.S predictor.c
  group ware/lib/Music/AAC
    ware/lib/Music/AAC/: aacbitstream.c aacbuffers.c aacdct4.c aacdec.c aacdecelmnt.c aacdequant.c aacfft.c aacfilefmt.c aachuffman.c aachufftabs.c aacimdct.c aacnoiseless.c aacpns.c aacsbr.c aacsbrfft.c aacsbrfreq.c aacsbrhfadj.c aacsbrhfgen.c aacsbrhuff.c aacsbrimdct.c aacsbrmath.c aacsbrqmf.c aacsbrside.c aacsbrtabs.c aacstproc.c aactabs.c aactns.c aactrigtabs.c aactrigtabs_fltgen.c sbrcov.s sbrqmfak.s sbrqmfsk.s
  group ware/lib/LVGL/widgets
    ware/lib/LVGL/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group ware/lib/LVGL/misc
    ware/lib/LVGL/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group ware/lib/LVGL/hal
    ware/lib/LVGL/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group ware/lib/LVGL/gpu
    ware/lib/LVGL/gpu/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_gpu_stm32_dma2d.c
  group ware/lib/LVGL/font
    ware/lib/LVGL/font/: Font12.c Font16.c Font20.c Font24.c Font36.c Font40.c Font48.c Font8.c lv_font.c lv_font_12.c lv_font_16.c lv_font_24.c lv_font_36.c lv_font_40.c lv_font_56.c lv_font_8.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_ipa.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group ware/lib/LVGL/extra
    ware/lib/LVGL/extra/: gifdec.c lodepng.c lv_animimg.c lv_bmp.c lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_chart.c lv_colorwheel.c lv_extra.c lv_flex.c lv_fs_fatfs.c lv_gif.c lv_grid.c lv_gridnav.c lv_imgbtn.c lv_keyboard.c lv_led.c lv_list.c lv_menu.c lv_meter.c lv_monkey.c lv_msgbox.c lv_png.c lv_snapshot.c lv_span.c lv_spinbox.c lv_spinner.c lv_tabview.c lv_theme_basic.c lv_theme_default.c lv_theme_mono.c lv_tileview.c lv_win.c
  group ware/lib/LVGL/draw
    ware/lib/LVGL/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group ware/lib/LVGL/core
    ware/lib/LVGL/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group ware/lib/LVGL/bsp
    ware/lib/LVGL/bsp/: lv_port_disp.c lv_port_indev.c
  group ware/lib/Letter_Shell
    ware/lib/Letter_Shell/: shell.c shell_cmd_list.c shell_ext.c
  group ware/lib/FreeRTOS
    ware/lib/FreeRTOS/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c list.c port.c queue.c rtos_timer.c stream_buffer.c tasks.c timers.c
  group ware/lib/FlashDB
    ware/lib/FlashDB/: fal.c fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group ware/lib/Fatfs
    ware/lib/Fatfs/: diskio.c fatfs.c ff.c ffsystem.c ffunicode.c
  group ware/lib/Cherry_USB/core
    ware/lib/Cherry_USB/core/: usbd_core.c usbh_core.c usbotg_core.c usb_dc_dwc2.c usb_glue_st.c usb_hc_dwc2.c usb_osal_freertos.c
  group ware/lib/Cherry_USB/class/wireless
    ware/lib/Cherry_USB/class/wireless/: usbd_rndis.c usbh_bluetooth.c usbh_rndis.c
  group ware/lib/Cherry_USB/class/video
    ware/lib/Cherry_USB/class/video/: usbd_video.c usbh_video.c
  group ware/lib/Cherry_USB/class/vendor/xbox
    ware/lib/Cherry_USB/class/vendor/xbox/: usbh_xbox.c
  group ware/lib/Cherry_USB/class/vendor/net
    ware/lib/Cherry_USB/class/vendor/net/: usbh_asix.c usbh_rtl8152.c
  group ware/lib/Cherry_USB/class/vendor/display
    ware/lib/Cherry_USB/class/vendor/display/: usbd_display.c
  group ware/lib/Cherry_USB/class/template
    ware/lib/Cherry_USB/class/template/: usbd_xxx.c usbh_xxx.c
  group ware/lib/Cherry_USB/class/serial
    ware/lib/Cherry_USB/class/serial/: usbh_cdc_acm.c usbh_ch34x.c usbh_cp210x.c usbh_ftdi.c usbh_gsm.c usbh_pl2303.c usbh_serial.c
  group ware/lib/Cherry_USB/class/msc
    ware/lib/Cherry_USB/class/msc/: usbd_msc.c usbh_fatfs.c usbh_msc.c
  group ware/lib/Cherry_USB/class/hub
    ware/lib/Cherry_USB/class/hub/: usbh_hub.c
  group ware/lib/Cherry_USB/class/hid
    ware/lib/Cherry_USB/class/hid/: usbd_hid.c usbh_hid.c
  group ware/lib/Cherry_USB/class/gamepad
    ware/lib/Cherry_USB/class/gamepad/: usbd_gamepad.c
  group ware/lib/Cherry_USB/class/dfu
    ware/lib/Cherry_USB/class/dfu/: usbd_dfu.c
  group ware/lib/Cherry_USB/class/cdc
    ware/lib/Cherry_USB/class/cdc/: usbd_cdc_acm.c usbd_cdc_ecm.c usbh_cdc_ecm.c usbh_cdc_ncm.c
  group ware/lib/Cherry_USB/class/audio
    ware/lib/Cherry_USB/class/audio/: usbd_audio.c usbh_audio.c
  group ware/lib/Cherry_USB/class/aoa
    ware/lib/Cherry_USB/class/aoa/: usbh_aoa.c
  group ware/lib/Cherry_USB/class/adb
    ware/lib/Cherry_USB/class/adb/: usbd_adb.c
  group ware/lib/AnimatedGIF
    ware/lib/AnimatedGIF/: AnimatedGIF.c
  group ware/GUI/GUI_Unit
    ware/GUI/GUI_Unit/: about_unit.c album_unit.c calculator_unit.c calendar_unit.c canvas_list_unit.c canvas_unit.c clock_unit.c cmd_unit.c control_center.c debug_unit.c desktop_unit.c es9018_unit.c file_unit.c font_update_unit.c icon_unit.c keyboard.c key_test_unit.c list_unit.c log_ctrl_unit.c lots_unit.c mem_unit.c music_unit.c navigation_bar.c note_list_unit.c note_unit.c serial_unit.c settings_unit.c start_unit.c status_bar.c text_unit.c time_set_unit.c usb_ctrl_unit.c words_unit.c
  group ware/GUI/GUI_Page
    ware/GUI/GUI_Page/: about_page.c album_page.c calculator_page.c calendar_page.c canvas_list_page.c canvas_page.c clock_page.c cmd_page.c debug_page.c desktop_page.c es9018_page.c file_page.c font_update_page.c key_test_page.c log_ctrl_page.c lots_page.c mem_monitor_page.c music_page.c note_list_page.c note_page.c page_manager.c serial_page.c settings_page.c start_page.c text_page.c time_set_page.c usb_page.c words_page.c
  group ware/GUI/GUI_Icons
    ware/GUI/GUI_Icons/: app_icon.c brahman_icon.c brahman_icon_edge.c canvas_icon.c control_center_icon.c file_icon.c music_icon.c navigation_icon.c pic_back.c pic_top.c status_bar_icon.c
  group ware/BSP
    ware/BSP/: adc.c es9018k2m.c i2s.c iwdg.c key.c lcd_bsp.c lcd_pwm.c max98357A.c nvic_conf.c pin_ctrl.c rng.c rtc_clock.c sdio_sdcard.c systick_conf.c w25q128.c
  group ware/APP/USB
    ware/APP/USB/: usbd_cdc_conf.c usbd_display_conf.c usbd_hid_conf.c usbd_msc_conf.c usbd_uac1_conf.c usbd_uac2_conf.c usbh_hid_conf.c usbh_msc_conf.c usbh_serial_conf.c
  group ware/APP/Text
    ware/APP/Text/: lrc.c program.c txt.c wordlist.c
  group ware/APP/NES
    ware/APP/NES/: 6502.s 6502mac.s cart.s equates.s nes_apu.c nes_main.c nes_mapper.c nes_ppu.c
  group ware/APP/NES/mapper
    ware/APP/NES/mapper/: 000.cpp 001.cpp 002.cpp 003.cpp 004.cpp 005.cpp 006.cpp 007.cpp 008.cpp 009.cpp 010.cpp 011.cpp 013.cpp 015.cpp 016.cpp 017.cpp 018.cpp 019.cpp 020.cpp 021.cpp 022.cpp 023.cpp 024.cpp 025.cpp 026.cpp 032.cpp 033.cpp 034.cpp 040.cpp 041.cpp 042.cpp 043.cpp 044.cpp 045.cpp 046.cpp 047.cpp 048.cpp 049.cpp 050.cpp 051.cpp 052.cpp 057.cpp 058.cpp 060.cpp 064.cpp 065.cpp 066.cpp 067.cpp 068.cpp 069.cpp 070.cpp 071.cpp 072.cpp 073.cpp 075.cpp 076.cpp 077.cpp 078.cpp 079.cpp 080.cpp 082.cpp 083.cpp 085.cpp 086.cpp 087.cpp 088.cpp 089.cpp 090.cpp 091.cpp 092.cpp 093.cpp 094.cpp 095.cpp 096.cpp 097.cpp 099.cpp 100.cpp 101.cpp 105.cpp 112.cpp 113.cpp 117.cpp 118.cpp 119.cpp 122.cpp 151.cpp 160.cpp 180.cpp 181.cpp 182.cpp 183.cpp 185.cpp 187.cpp 188.cpp 189.cpp 225.cpp 226.cpp 227.cpp 228.cpp 229.cpp 230.cpp 231.cpp 232.cpp 233.cpp 234.cpp 235.cpp 236.cpp 237.cpp 240.cpp 242.cpp 243.cpp 245.cpp 246.cpp 248.cpp 255.cpp NSF.cpp
  group ware/APP/Music
    ware/APP/Music/: aac.c aiff.c ape.c flac.c mp3.c music.c ogg.c wav.c
  group ware/APP/Media
    ware/APP/Media/: avi.c bmp.c gif.c jpg.c mjpeg.c png.c video.c
  group start
    start/: arm_common_tables.h arm_const_structs.h arm_cortexM4lf_math.lib arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group library
    library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
